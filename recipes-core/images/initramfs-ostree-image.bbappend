# avoid circular dependencies
IMAGE_FSTYPES_remove = "wic wic.gz wic.bmap ext4 ext4.gz"
EXTRA_IMAGEDEPENDS = ""
